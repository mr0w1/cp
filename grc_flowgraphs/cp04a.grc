<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>cp04a</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>CP v0.4a</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>ch1_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>freq</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Ch1 Freq</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>ch1_invert</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>1</value></param>
<param><key>grid_pos</key><value>0,4,1,1</value></param>
<param><key>label</key><value>Invert</value></param>
<param><key>true</key><value>-1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>ch1_modulation</value></param>
<param><key>choices</key><value>[0, 1,2]</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Modulation</value></param>
<param><key>labels</key><value>["DMR","NBFM","WBFM"]</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>drop_down</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>ch1_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>1</value></param>
<param><key>grid_pos</key><value>0,5,1,1</value></param>
<param><key>label</key><value>Mute</value></param>
<param><key>true</key><value>0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ch1_squelch</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>-30</value></param>
<param><key>grid_pos</key><value>0,3,1,1</value></param>
<param><key>label</key><value>Squelch</value></param>
<param><key>max</key><value>0</value></param>
<param><key>min</key><value>-70</value></param>
<param><key>num_steps</key><value>14</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ch1_volume</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>1</value></param>
<param><key>grid_pos</key><value>0,2,1,1</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>max</key><value>10</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>40</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>ch2_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>freq</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Ch2 Freq</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>ch2_invert</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>1</value></param>
<param><key>grid_pos</key><value>1,4,1,1</value></param>
<param><key>label</key><value>Invert</value></param>
<param><key>true</key><value>-1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>ch2_modulation</value></param>
<param><key>choices</key><value>[0, 1,2]</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Modulation</value></param>
<param><key>labels</key><value>["DMR","NBFM","WBFM"]</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>drop_down</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>ch2_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>1</value></param>
<param><key>grid_pos</key><value>1,5,1,1</value></param>
<param><key>label</key><value>Mute</value></param>
<param><key>true</key><value>0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ch2_squelch</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>-30</value></param>
<param><key>grid_pos</key><value>1,3,1,1</value></param>
<param><key>label</key><value>Squelch</value></param>
<param><key>max</key><value>0</value></param>
<param><key>min</key><value>-70</value></param>
<param><key>num_steps</key><value>14</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ch2_volume</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>1</value></param>
<param><key>grid_pos</key><value>1,2,1,1</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>max</key><value>10</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>20</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>ch3_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>freq</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
<param><key>label</key><value>Ch3 Freq</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>ch3_invert</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>1</value></param>
<param><key>grid_pos</key><value>2,4,1,1</value></param>
<param><key>label</key><value>Invert</value></param>
<param><key>true</key><value>-1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>ch3_modulation</value></param>
<param><key>choices</key><value>[0, 1,2]</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>2,1,1,1</value></param>
<param><key>label</key><value>Modulation</value></param>
<param><key>labels</key><value>["DMR","NBFM","WBFM"]</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>drop_down</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>ch3_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>1</value></param>
<param><key>grid_pos</key><value>2,5,1,1</value></param>
<param><key>label</key><value>Mute</value></param>
<param><key>true</key><value>0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ch3_squelch</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>-30</value></param>
<param><key>grid_pos</key><value>2,3,1,1</value></param>
<param><key>label</key><value>Squelch</value></param>
<param><key>max</key><value>0</value></param>
<param><key>min</key><value>-70</value></param>
<param><key>num_steps</key><value>14</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ch3_volume</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>1</value></param>
<param><key>grid_pos</key><value>2,2,1,1</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>max</key><value>10</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>20</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>ch4_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>freq</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,0,1,1</value></param>
<param><key>label</key><value>Ch4 Freq</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>ch4_invert</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>1</value></param>
<param><key>grid_pos</key><value>3,4,1,1</value></param>
<param><key>label</key><value>Invert</value></param>
<param><key>true</key><value>-1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>ch4_modulation</value></param>
<param><key>choices</key><value>[0, 1,2]</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>3,1,1,1</value></param>
<param><key>label</key><value>Modulation</value></param>
<param><key>labels</key><value>["DMR","NBFM","WBFM"]</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>drop_down</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>ch4_mute</value></param>
<param><key>value</key><value>1</value></param>
<param><key>false</key><value>1</value></param>
<param><key>grid_pos</key><value>3,5,1,1</value></param>
<param><key>label</key><value>Mute</value></param>
<param><key>true</key><value>0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ch4_squelch</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>-30</value></param>
<param><key>grid_pos</key><value>3,3,1,1</value></param>
<param><key>label</key><value>Squelch</value></param>
<param><key>max</key><value>0</value></param>
<param><key>min</key><value>-70</value></param>
<param><key>num_steps</key><value>14</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ch4_volume</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>1</value></param>
<param><key>grid_pos</key><value>3,2,1,1</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>max</key><value>10</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>20</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>92.9e6</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>21,0,1,10</value></param>
<param><key>label</key><value>Radio Center Freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_0</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>ch1_squelch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_0_0</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>ch2_squelch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_0_0_0</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>ch3_squelch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>analog_pwr_squelch_xx_0_0_0_0_0</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>gate</key><value>True</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>threshold</key><value>ch4_squelch</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0_0_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>3</value></param>
<param><key>output_index</key><value>ch1_modulation</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0</value></param>
<param><key>input_index</key><value>ch1_modulation</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0_0</value></param>
<param><key>input_index</key><value>ch2_modulation</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0_0_0</value></param>
<param><key>input_index</key><value>ch3_modulation</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0_0_0_0</value></param>
<param><key>input_index</key><value>ch4_modulation</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_1</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>3</value></param>
<param><key>output_index</key><value>ch2_modulation</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_1_0</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>3</value></param>
<param><key>output_index</key><value>ch3_modulation</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_1_0_0</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>3</value></param>
<param><key>output_index</key><value>ch4_modulation</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>ch1_volume</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>ch2_volume</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0</value></param>
<param><key>const</key><value>ch3_volume</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0_0_0</value></param>
<param><key>const</key><value>ch4_volume</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>ch1_invert * ch1_mute</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>ch2_invert * ch2_mute</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2_0</value></param>
<param><key>const</key><value>ch3_invert * ch3_mute</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2_0_0</value></param>
<param><key>const</key><value>ch4_invert * ch4_mute</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>dsd_chain</key>
<param><key>id</key><value>dsd_chain_0</value></param>
</block>
<block>
<key>dsd_chain</key>
<param><key>id</key><value>dsd_chain_1</value></param>
</block>
<block>
<key>dsd_chain</key>
<param><key>id</key><value>dsd_chain_1_0</value></param>
</block>
<block>
<key>dsd_chain</key>
<param><key>id</key><value>dsd_chain_1_0_0</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_0</value></param>
<param><key>center_freq</key><value>ch1_freq - freq</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1,samp_rate,200000,10000)</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_0_0</value></param>
<param><key>center_freq</key><value>ch2_freq - freq</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1,samp_rate,200000,10000)</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_0_0_0</value></param>
<param><key>center_freq</key><value>ch3_freq - freq</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1,samp_rate,200000,10000)</value></param>
</block>
<block>
<key>freq_xlating_fft_filter_ccc</key>
<param><key>id</key><value>freq_xlating_fft_filter_ccc_0_0_0_0</value></param>
<param><key>center_freq</key><value>ch4_freq - freq</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1,samp_rate,200000,10000)</value></param>
</block>
<block>
<key>nbfm_chain</key>
<param><key>id</key><value>nbfm_chain_0</value></param>
</block>
<block>
<key>nbfm_chain</key>
<param><key>id</key><value>nbfm_chain_1</value></param>
</block>
<block>
<key>nbfm_chain</key>
<param><key>id</key><value>nbfm_chain_1_0</value></param>
</block>
<block>
<key>nbfm_chain</key>
<param><key>id</key><value>nbfm_chain_1_0_0</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>tab</value></param>
<param><key>grid_pos</key><value>5,0,1,7</value></param>
<param><key>labels</key><value>['Ch 1', 'Ch 2','Ch 3','Ch 4']</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
</block>
<block>
<key>wbfm_chain</key>
<param><key>id</key><value>wbfm_chain_0</value></param>
</block>
<block>
<key>wbfm_chain</key>
<param><key>id</key><value>wbfm_chain_0_0</value></param>
</block>
<block>
<key>wbfm_chain</key>
<param><key>id</key><value>wbfm_chain_0_0_0</value></param>
</block>
<block>
<key>wbfm_chain</key>
<param><key>id</key><value>wbfm_chain_0_0_0_0</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0.1333</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>ch1_freq</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,12,7</value></param>
<param><key>notebook</key><value>tab,0</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>Channel 1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>avg_alpha</key><value>0.1333</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,12,7</value></param>
<param><key>notebook</key><value>tab,1</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>Channel 2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0_0</value></param>
<param><key>avg_alpha</key><value>0.1333</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,12,7</value></param>
<param><key>notebook</key><value>tab,2</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>Channel 3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0_0_0</value></param>
<param><key>avg_alpha</key><value>0.1333</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,12,7</value></param>
<param><key>notebook</key><value>tab,3</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>Channel 4</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_1</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>grid_pos</key><value>6,0,15,10</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
</block>
<connection><source_block_id>analog_pwr_squelch_xx_0_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_0_0</source_block_id><sink_block_id>blks2_selector_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_0_0_0</source_block_id><sink_block_id>blks2_selector_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pwr_squelch_xx_0_0_0_0_0</source_block_id><sink_block_id>blks2_selector_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>dsd_chain_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>nbfm_chain_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>wbfm_chain_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_1</source_block_id><sink_block_id>dsd_chain_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_1</source_block_id><sink_block_id>nbfm_chain_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_1</source_block_id><sink_block_id>wbfm_chain_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_1_0</source_block_id><sink_block_id>dsd_chain_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_1_0</source_block_id><sink_block_id>nbfm_chain_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_1_0</source_block_id><sink_block_id>wbfm_chain_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_1_0_0</source_block_id><sink_block_id>dsd_chain_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_1_0_0</source_block_id><sink_block_id>nbfm_chain_1_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_1_0_0</source_block_id><sink_block_id>wbfm_chain_0_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2_0</source_block_id><sink_block_id>audio_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2_0_0</source_block_id><sink_block_id>audio_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dsd_chain_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dsd_chain_1</source_block_id><sink_block_id>blks2_selector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dsd_chain_1_0</source_block_id><sink_block_id>blks2_selector_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dsd_chain_1_0_0</source_block_id><sink_block_id>blks2_selector_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0_0_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0_0_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0_0_0_0</source_block_id><sink_block_id>analog_pwr_squelch_xx_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fft_filter_ccc_0_0_0_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nbfm_chain_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>nbfm_chain_1</source_block_id><sink_block_id>blks2_selector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>nbfm_chain_1_0</source_block_id><sink_block_id>blks2_selector_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>nbfm_chain_1_0_0</source_block_id><sink_block_id>blks2_selector_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>freq_xlating_fft_filter_ccc_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>wxgui_waterfallsink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wbfm_chain_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>wbfm_chain_0_0</source_block_id><sink_block_id>blks2_selector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>wbfm_chain_0_0_0</source_block_id><sink_block_id>blks2_selector_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>wbfm_chain_0_0_0_0</source_block_id><sink_block_id>blks2_selector_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
</flow_graph>
